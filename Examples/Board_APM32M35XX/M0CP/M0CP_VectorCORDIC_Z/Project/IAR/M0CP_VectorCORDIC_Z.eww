<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M0CP_VectorCORDIC_Z.ewp</path>
    </project>
    <batchBuild />
</workspace>
