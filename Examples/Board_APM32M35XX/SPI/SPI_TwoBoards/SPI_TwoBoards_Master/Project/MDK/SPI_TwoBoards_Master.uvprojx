# Keil uVision project SPI_TwoBoards_Master.uvprojx, settings and files
target APM32M35XX (6220000::V6.22::ARMCLANG)
  device: APM32M3514C8 Geehy
  pack: Geehy.APM32M35XX_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SPI_TwoBoards_Master
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOARD_APM32M35XX_MINI,APM32M35XX
  c include: ..\..\..\..\..\..\..\Boards;..\..\..\..\..\..\..\Boards\Board_APM32M35XX\inc;..\..\Include;..\..\..\..\..\..\..\Libraries\APM32M35XX_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32M35XX\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32m35xx.c
    ../../../../../../../Libraries/Device/Geehy/APM32M35XX/Source/arm/: startup_apm32m35xx.s
  group StdPeriphLib
    ../../../../../../../Libraries/APM32M35XX_StdPeriphDriver/src/: apm32m35xx_adc.c apm32m35xx_can.c apm32m35xx_comp.c apm32m35xx_crc.c apm32m35xx_dbg.c apm32m35xx_dma.c apm32m35xx_eint.c apm32m35xx_fmc.c apm32m35xx_gpio.c apm32m35xx_i2c.c apm32m35xx_iwdt.c apm32m35xx_m0cp.c apm32m35xx_misc.c apm32m35xx_ob.c apm32m35xx_opa.c apm32m35xx_pmu.c apm32m35xx_rcm.c apm32m35xx_rtc.c apm32m35xx_spi.c apm32m35xx_syscfg.c apm32m35xx_tmr.c apm32m35xx_usart.c apm32m35xx_wwdt.c
  group Boards
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32M35XX/src/: bsp_delay.c
  group Application
    ../../Source/: main.c apm32m35xx_int.c
