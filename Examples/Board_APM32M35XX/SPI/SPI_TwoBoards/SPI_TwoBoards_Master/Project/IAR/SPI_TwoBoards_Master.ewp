# IAR project SPI_TwoBoards_Master.ewp, settings and files
configuration APM32M35XX (ARM, debug)
  General.OGChipSelectEditMenu: APM32M3514C8 Geehy APM32M3514C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32M35XX_MINI; APM32M35XX
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Boards\Board_APM32M35XX\inc; ..\..\Include; ..\..\..\..\..\..\..\Libraries\APM32M35XX_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32M35XX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_TwoBoards_Master.srec
  ILINK.IlinkOutputFile: SPI_TwoBoards_Master.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32m35xx_int.c main.c
  group Boards
    ../../../../../../../Boards/: board.c
    ../../../../../../../Boards/Board_APM32M35XX/src/: bsp_delay.c
  group CMSIS
    ../../../../../../../Libraries/Device/Geehy/APM32M35XX/Source/iar/: startup_apm32m35xx.s
    ../../Source/: system_apm32m35xx.c
  group StdPeriphLib
    ../../../../../../../Libraries/APM32M35XX_StdPeriphDriver/src/: apm32m35xx_adc.c apm32m35xx_can.c apm32m35xx_comp.c apm32m35xx_crc.c apm32m35xx_dbg.c apm32m35xx_dma.c apm32m35xx_eint.c apm32m35xx_fmc.c apm32m35xx_gpio.c apm32m35xx_i2c.c apm32m35xx_iwdt.c apm32m35xx_m0cp.c apm32m35xx_misc.c apm32m35xx_ob.c apm32m35xx_opa.c apm32m35xx_pmu.c apm32m35xx_rcm.c apm32m35xx_rtc.c apm32m35xx_spi.c apm32m35xx_syscfg.c apm32m35xx_tmr.c apm32m35xx_usart.c apm32m35xx_wwdt.c
