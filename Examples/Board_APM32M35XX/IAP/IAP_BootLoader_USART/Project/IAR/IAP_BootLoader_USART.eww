<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IAP_BootLoader_USART.ewp</path>
    </project>
    <batchBuild />
</workspace>
